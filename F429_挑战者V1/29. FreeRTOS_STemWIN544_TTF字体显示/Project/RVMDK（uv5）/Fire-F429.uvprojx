# Keil uVision project Fire-F429.uvprojx, settings and files
target Fire-F429 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fire-F429 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,OS_SUPPORT
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM4F;..\..\STemWin\Config;..\..\STemWin\inc;..\..\STemWin\Application;..\..\STemWin_Task;..\..\FATFS;..\..\STemWin\truetype
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h
  group BSP
    ../../User/led/: bsp_led.c
    ../../User/usart/: bsp_debug_usart.c
    ../../User/beep/: bsp_beep.c
    ../../User/key/: bsp_key.c
    ../../User/lcd/: bsp_lcd.c
    ../../User/sdram/: bsp_sdram.c
    ../../User/touch/: bsp_i2c_touch.c gt9xx.c
    ../../User/TouchPad/: bsp_touchpad.c
    ../../User/flash/: bsp_spi_flash.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group STemWIN
    ../../STemWin/Config/: GUIConf.c GUIConf.h GUIDRV_wf.c
    ../../STemWin/OS/: GUI_X_FreeRTOS.c
    ../../STemWin/Lib/: STemWin_CM4_OS_wc16_ot_ARGB.a
  group STemWIN/Task
    ../../STemWin_Task/: GUIFont_Create.c MainTask.c ScreenShot.c text.c
  group STemWIN/truetype
    ../../STemWin/truetype/: autofit.c bdf.c cff.c ftbase.c ftbbox.c ftbdf.c ftbitmap.c ftbzip2.c ftcache.c ftcid.c ftdebug.c ftfstype.c ftgasp.c ftglyph.c ftgxval.c ftgzip.c ftinit.c ftlcdfil.c ftlzw.c ftmm.c ftotval.c ftpatent.c ftpfr.c ftstroke.c ftsynth.c ftsystem.c fttype1.c ftwinfnt.c ftxf86.c GUI_TTF.c gxvalid.c otvalid.c pcf.c pfr.c psaux.c pshinter.c psnames.c raster.c sfnt.c smooth.c truetype.c type1.c type1cid.c type42.c winfnt.c
  group FatFS
    ../../FATFS/: diskio.c ff.c
    ../../FATFS/drivers/: fatfs_sd_sdio.c
    ../../FATFS/option/: cc936.c
  group DOC
    ../../: 必读说明.txt
